# Keil uVision project LEDMatrixBluetooth.uvprojx, settings and files
target LEDMatrixBluetooth (5060020::V5.06 (build 20)::ARMCC)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LEDMatrixBluetooth
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: L0_matrix_driver.h L0_matrix_driver.c L0_gpio_init.c L0_gpio_init.h L1_image_processing.h L1_image_processing.c L0_uart_init.c main.c L0_uart.c config.h
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0, Device:XMClib:GPIO 2.0.0, Device:XMClib:SCU 2.0.0, Device:XMClib:UART 2.0.0
